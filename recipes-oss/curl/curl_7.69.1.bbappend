PACKAGECONFIG:append = " libssh2"
